# Keil uVision project LT-ARM.uvproj, settings and files
target STM32F303VC (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: LT-ARM
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group CMSIS
    ./CMSIS/Basic+StdPeriph/: startup_stm32f30x.s stm32f30x.h stm32f30x_gpio.h stm32f30x_gpio.c stm32f30x_rcc.c stm32f30x_rcc.h system_stm32f30x.c system_stm32f30x.h stm32f30x_tim.c stm32f30x_tim.h stm32f30x_misc.c
  group Source Files
    ./: main.cpp LTAR_Ser_Block.cpp LTAR_Ser_Rx.cpp LTAR_Ser_Tx.cpp
